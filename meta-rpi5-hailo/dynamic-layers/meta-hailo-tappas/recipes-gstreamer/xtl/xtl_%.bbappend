# The recipe sets LICENSE = "LICENSE", which resolves to the Hailo TAPPAS
# license that meta-hailo-tappas puts in LICENSE_PATH. xtl is BSD-3-Clause:
# the LICENSE file that LIC_FILES_CHKSUM already checks is the BSD 3-clause text.
LICENSE = "BSD-3-Clause"
